# Keil uVision project app_216.uvprojx, settings and files
target GR5515_SK (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: oppo_pencil +hex
  AfterMake: fromelf.exe --bin --output ..\..\..\image\application\ble\@L.bin Objects\@L.axf
  AfterMake: ..\..\..\image\application\make_image_216.bat
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5515_SK,USE_SECOND_BOOT_MODE,DIS_MAXEYE_LICENSE_VERIFY,COMBINDED_FIRMWARE_ENABLE
  c include: ..\Src\config;..\Src\platform;..\Src\user;..\Src\config;..\..\..\..\GR551x_SDK_V1.7.0\components\app_drivers\inc;..\..\..\..\GR551x_SDK_V1.7.0\components\boards;..\..\..\..\GR551x_SDK_V1.7.0\components\drivers_ext\gr551x;..\..\..\..\GR551x_SDK_V1.7.0\components\drivers_ext\st7735;..\..\..\..\GR551x_SDK_V1.7.0\components\drivers_ext\vs1005;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_alarm;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_assert;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_error;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_key;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_log;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_queue;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\app_timer;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\at_cmd;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\bsp;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\dfu_master;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\dfu_port;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\gui;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\gui\gui_config;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\hal_flash;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\hci_uart;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\pmu_calibration;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\ring_buffer;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\sensorsim;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\utility;..\..\..\..\GR551x_SDK_V1.7.0\components\patch\ind;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ams_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ancs_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ans;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ans_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\bas;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\bas_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\bcs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\bps;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\common;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\cscs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\cts;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\cts_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\dis;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\dis_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\gls;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\gus;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\gus_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\hids;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\hrrcps;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\hrs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\hrs_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\hts;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ias;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\lls;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ndcs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\otas;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\otas_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\pass;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\pass_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\pcs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\rscs;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\rscs_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\rtus;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\sample;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ths;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\ths_c;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\thscps;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\tps;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\wechat;..\..\..\..\GR551x_SDK_V1.7.0\components\sdk\;..\..\..\..\GR551x_SDK_V1.7.0\drivers\inc;..\..\..\..\GR551x_SDK_V1.7.0\external\freertos\include;..\..\..\..\GR551x_SDK_V1.7.0\external\segger_rtt;..\..\..\..\GR551x_SDK_V1.7.0\toolchain\cmsis\include;..\..\..\..\GR551x_SDK_V1.7.0\toolchain\gr551x\include;..\..\..\..\GR551x_SDK_V1.7.0\toolchain\gr551x\source\arm;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\ble\common;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\ble\ble_advertising;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\ble\ble_connect;..\Src\maxeye\inc;..\Src\maxeye_drivers\inc;..\Src\fatfs;..\..\..\..\GR551x_SDK_V1.7.0\external\fat_fs\src;..\..\..\..\GR551x_SDK_V1.7.0\external\fat_fs\src\drivers;..\..\..\..\GR551x_SDK_V1.7.0\components\libraries\fault_trace;..\..\..\..\GR551x_SDK_V1.7.0\components\profiles\lns;..\Src\maxeye\inc\version_216;..\Src\user\usr_log;..\Src\user\promise
  library: MicroLIB
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: ..\..\..\..\GR551x_SDK_V1.7.0\toolchain\gr551x\source\arm\flash_scatter_common.sct
  link misc: ..\..\..\..\GR551x_SDK_V1.7.0\components\patch\symbol_table\rom_symbol.txt
  group user_app
    ../Src/user/: main.c user_app.c
    ./../Src/config/: custom_config.h
    ../../../../GR551x_SDK_V1.7.0/components/boards/: GR5515_SK.h
  group user_platform
    ../Src/platform/: user_periph_setup.c
  group user_callbacks
    ../Src/user_callback/: user_gap_callback.c user_sm_callback.c
    ../../../../GR551x_SDK_V1.7.0/components/patch/app_gapc_hci_patch/: app_gapc_hci_patch.c
  group maxeye
    ../Src/maxeye/src/: maxeye_18092D_services.c maxeye_180933_services.c maxeye_540500_services.c maxeye_battery.c maxeye_ble.c maxeye_ble_cli.c maxeye_dfu.c maxeye_fatfs.c maxeye_gpio.c maxeye_io_it.c maxeye_mcu_stylus.c maxeye_mcu_upgrade.c maxeye_notify.c maxeye_public_services.c maxeye_sensor.c maxeye_sleep.c maxeye_touch.c maxeye_touch_cli.c maxeye_touch_upgrade.c maxeye_uart.c maxeye_wdt.c maxeye_wlc.c maxeye_nvds.c maxeye_product_test.c
    ../Src/maxeye/inc/: maxeye_version.h maxeye_common.h
    ../Src/maxeye_drivers/src/: maxeye_cw221x_cmd.c
  group maxeye_drivers
    ../Src/maxeye_drivers/src/: lis2dh12.c maxeye_cw221x.c maxeye_ft3308.c maxeye_i2c0.c maxeye_mp2662.c maxeye_ra9520.c
  group fatfs
    ../../../../GR551x_SDK_V1.7.0/external/fat_fs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../GR551x_SDK_V1.7.0/external/fat_fs/src/drivers/: flash_diskio.c
    ../Src/fatfs/: fatfs_flash_drv.c
  group gr_startup
    ../../../../GR551x_SDK_V1.7.0/toolchain/gr551x/source/arm/: startup_gr55xx.s
  group gr_arch
    ../../../../GR551x_SDK_V1.7.0/toolchain/gr551x/source/: interrupt_gr55xx.c system_gr55xx.c platform_gr55xx.c
  group gr_stack_lib
    ../../../../GR551x_SDK_V1.7.0/components/sdk/linker/lib/: ble_sdk.lib
  group gr_drivers
    ../../../../GR551x_SDK_V1.7.0/drivers/src/: gr55xx_hal.c gr55xx_hal_exflash.c gr55xx_hal_xqspi.c gr55xx_hal_pwr.c gr55xx_hal_gpio.c gr55xx_hal_aon_gpio.c gr55xx_hal_uart.c gr55xx_hal_i2c.c gr55xx_hal_aon_wdt.c gr55xx_hal_tim.c gr55xx_hal_calendar.c
  group gr_app_drivers
    ../../../../GR551x_SDK_V1.7.0/components/app_drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_systick.c app_i2c.c app_tim.c
  group gr_libraries
    ../../../../GR551x_SDK_V1.7.0/components/libraries/utility/: utility.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/sensorsim/: sensorsim.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/app_timer/: app_timer.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/ring_buffer/: ring_buffer.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/app_log/: app_log.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/app_error/: app_error.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/app_assert/: app_assert.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/bsp/: bsp.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/app_key/: app_key.c app_key_core.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/dfu_port/: dfu_port.c
    ../../../../GR551x_SDK_V1.7.0/components/app_drivers/src/: app_rtc.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/app_queue/: app_queue.c
    ../../../../GR551x_SDK_V1.7.0/components/libraries/fault_trace/: fault_trace.c
  group gr_profiles
    ../../../../GR551x_SDK_V1.7.0/components/profiles/common/: ble_prf_utils.c
    ../../../../GR551x_SDK_V1.7.0/components/profiles/hids/: hids.c
    ../../../../GR551x_SDK_V1.7.0/components/profiles/bas/: bas.c
    ../../../../GR551x_SDK_V1.7.0/components/profiles/dis/: dis.c
    ../../../../GR551x_SDK_V1.7.0/components/profiles/otas/: otas.c
  group external
    ../../../../GR551x_SDK_V1.7.0/external/segger_rtt/: SEGGER_RTT.c
  group user/log
    ../Src/user/usr_log/: user_log.c
  group user/promise
    ../Src/user/promise/: promise.c
